options:
  parameters:
    generate_options: qt_gui
    id: hackrf_output
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: am_modulation_factor
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: filter_low
  id: variable_qtgui_range
  parameters:
    start: '-5e6'
    step: 1e5
    stop: 0.5e6
    value: '-1.25e6'
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 1e4
    stop: 4e6
    value: 2.25e6
  states: {}
- name: frequency_tune
  id: variable_qtgui_range
  parameters:
    start: 150e6
    step: 1e6
    stop: 200e6
    value: 182.225e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 27.75e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: am_modulation_factor
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: am_modulation_factor
    type: complex
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/johannes/git/pal-encode/futuresdr_dump.f32
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/johannes/git/pal-encode/data.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e6
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: frequency_tune
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate/decimation
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '256'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: complex
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '11'
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: frequency_tune
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:1338
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_copy_0, '0', osmosdr_sink_0, '0']
- [blocks_copy_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_copy_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_copy_0_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_1, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_sub_xx_0, '1']
- [blocks_interleaved_char_to_complex_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_sub_xx_0, '1']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_sub_xx_0, '0', blocks_copy_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', blocks_copy_0, '0']
- [root_raised_cosine_filter_0, '0', low_pass_filter_0, '0']
- [zeromq_sub_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
