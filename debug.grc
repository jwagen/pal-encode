options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/johannes/git/pal-encode/data.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_1
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Bandwidth
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '150'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '150'
    ymin: '-150'
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_interleaved_char_to_complex_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_null_sink_0, '0']

metadata:
  file_format: 1
